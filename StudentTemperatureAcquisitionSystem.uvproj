# Keil uVision project StudentTemperatureAcquisitionSystem.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: StudentTemperatureAcquisitionSystem +hex
  c flags: Optimize=8 SizeSpeed=1
  group MAIN
    ./src/: main.c
  group AT24C02
    ./src/: at24c02.c
  group BEEP
    ./src/: beep.c
  group DS18B20
    ./src/: ds18b20.c
  group LCD1602
    ./src/: lcd1602.c
  group RC522
    ./src/: rc522.c
